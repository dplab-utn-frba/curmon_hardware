# Repository dplab-utn-frba/curmon_hardware

File README.md:

curmon_hardware
===============

Hardware del Monitor de Corriente

DPLab-UTN-FRBA

## KiCad design pcb/sensCorriente.kicad_pcb

Parts:
C1: 1uF
C2, C3, C4, C5, C7, C8, C9, C10, C11, C12, C13: 100nF
C6: TBD
J1: I_in
J2: USB
J3: CONECTORSD; sdcard
J4: DB9
P1: LPCXpresso
R1, R2, R3, R4, R5, R6, R7, R9, R10: 10k
R8: 100
RV1: POT
S1: Display 16x2
SW1: CALIB
U1: ACS713
U2: MAX232

Connections:
+3.3V: C1.2, C2.2, J3.4, P1.28, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R9.2, R10.2
+5V: C3.2, C5.2, C9.2, J2.1 (Vbus), P1.2, R8.2, RV1.1, S1.2 (VCC), U1.8 (Vcc), U2.16 (VCC)
/AIN0: C7.2, P1.15, R7.2
/CALIB: C4.2, P1.21, SW1.2
/CTS1: P1.12, U2.9 (R2OUT)
/LCD_D4: P1.47, S1.11 (D4)
/LCD_D5: P1.48, S1.12 (D5)
/LCD_D6: P1.49, S1.13 (D6)
/LCD_D7: P1.50, S1.14 (D7)
/LCD_E: P1.43, S1.6 (CS)
/LCD_RS: P1.42, S1.4 (RS)
/RTS1: P1.24, U2.10 (T2IN)
/RXD1: P1.14, U2.12 (R1OUT)
/SD_CD: C12.2, J3.10, P1.52, R9.1
/SD_CLK: J3.5, P1.7, R2.1
/SD_MISO: J3.7, P1.6, R1.1
/SD_MOSI: J3.2, P1.5, R3.1
/SD_SSEL: J3.1, P1.8, R4.1
/SD_WP: C13.2, J3.11, P1.53, R10.1
/TXD1: P1.13, U2.11 (T1IN)
/USB_D+: J2.3 (D+), P1.37
/USB_D-: J2.2 (D-), P1.36
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C11.2, C12.1, C13.1, J2.4 (GND), J2.5 (Shield_1), J2.6 (Shield_2), J3.3, J3.6, P1.1, P1.54, RV1.3, S1.1 (GND), S1.5 (R/W), S1.K, SW1.1, U1.5 (GND), U2.15 (GND)
unnamed: R7.1, U1.7 (VOUT)
unnamed: C6.2, U1.6 (FILTER)
unnamed: RV1.2, S1.3 (VLCD)
unnamed: C11.1, U2.6 (V-)
unnamed: C9.1, U2.2 (V+)
unnamed: C10.2, U2.4 (C2+)
unnamed: C10.1, U2.5 (C2-)
unnamed: C8.2, U2.1 (C1+)
unnamed: C8.1, U2.3 (C1-)
unnamed: J3.8, R5.1
unnamed: J4.8, U2.8 (R2IN)
unnamed: J4.2, U2.14 (T1OUT)
unnamed: J4.7, U2.7 (T2OUT)
unnamed: J4.3, U2.13 (R1IN)
unnamed: J3.9, R6.1
unnamed: R8.1, S1.A
unnamed: J1.2, U1.3 (IP-), U1.4 (IP-)
unnamed: J1.1, U1.1 (IP+), U1.2 (IP+)

Board: 2 copper layers, 33 parts (1 on the bottom side), 41 nets.

## Commit log

2014-08-29 Commit inicial.
2014-08-29 README actualizado.
2014-08-29 Netlist generado de prueba.
2014-08-29 Netlist generado de prueba, archivo agregado.
2014-09-02 LPCXpresso footprint and association files created.
2014-09-03 Added serial interface.
2014-09-09 se actualizo archivo de asociacion simbolo footprint
2014-09-10 Asociacion de footprints finalizada. Se agregaron hojas de datos de display y conector SD.
2014-09-12 Corregido footprint de RV1 y J4.
2014-09-12 Placing de componentes terminado.
2014-09-12 Comienzo de roteo.
2014-09-23 Avance en el trazado de vias.
2014-09-26 Prueba usurio german
2014-09-26 Trazado preliminar
2014-09-26 Vias 5V modificadas.
2014-10-24 Footprint del conector SD realizado.
2014-10-24 Se realizaron cambios en el esquematico. Revisar ERC.
2014-10-31 Primer version del pcb terminado. Verificar y realizar correcciones. ERC OK en el esquematico y en el pcb.
2015-10-20 Incorpore el cape de la BeagleBone
